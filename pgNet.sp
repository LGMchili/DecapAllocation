r1 n1 n2 0.25
r2 n2 n3 0.25
r3 n3 n4 0.25
r4 n4 n5 0.25
r5 n5 n6 0.25
r6 n6 n7 0.25
r7 n7 n8 0.25
r8 n8 n9 0.25
r9 n9 n10 0.25
r10 n10 n11 0.25
r11 n11 n12 0.25
r12 n12 n13 0.25
r13 n13 n14 0.25
r14 n14 n15 0.25
r15 n15 n16 0.25
r16 n16 n17 0.25
r17 n17 n18 0.25
r18 n18 n19 0.25
r19 n19 n20 0.25
r20 n21 n22 0.25
r21 n22 n23 0.25
r22 n23 n24 0.25
r23 n24 n25 0.25
r24 n25 n26 0.25
r25 n26 n27 0.25
r26 n27 n28 0.25
r27 n28 n29 0.25
r28 n29 n30 0.25
r29 n30 n31 0.25
r30 n31 n32 0.25
r31 n32 n33 0.25
r32 n33 n34 0.25
r33 n34 n35 0.25
r34 n35 n36 0.25
r35 n36 n37 0.25
r36 n37 n38 0.25
r37 n38 n39 0.25
r38 n39 n40 0.25
r39 n41 n42 0.25
r40 n42 n43 0.25
r41 n43 n44 0.25
r42 n44 n45 0.25
r43 n45 n46 0.25
r44 n46 n47 0.25
r45 n47 n48 0.25
r46 n48 n49 0.25
r47 n49 n50 0.25
r48 n50 n51 0.25
r49 n51 n52 0.25
r50 n52 n53 0.25
r51 n53 n54 0.25
r52 n54 n55 0.25
r53 n55 n56 0.25
r54 n56 n57 0.25
r55 n57 n58 0.25
r56 n58 n59 0.25
r57 n59 n60 0.25
r58 n61 n62 0.25
r59 n62 n63 0.25
r60 n63 n64 0.25
r61 n64 n65 0.25
r62 n65 n66 0.25
r63 n66 n67 0.25
r64 n67 n68 0.25
r65 n68 n69 0.25
r66 n69 n70 0.25
r67 n70 n71 0.25
r68 n71 n72 0.25
r69 n72 n73 0.25
r70 n73 n74 0.25
r71 n74 n75 0.25
r72 n75 n76 0.25
r73 n76 n77 0.25
r74 n77 n78 0.25
r75 n78 n79 0.25
r76 n79 n80 0.25
r77 n81 n82 0.25
r78 n82 n83 0.25
r79 n83 n84 0.25
r80 n84 n85 0.25
r81 n85 n86 0.25
r82 n86 n87 0.25
r83 n87 n88 0.25
r84 n88 n89 0.25
r85 n89 n90 0.25
r86 n90 n91 0.25
r87 n91 n92 0.25
r88 n92 n93 0.25
r89 n93 n94 0.25
r90 n94 n95 0.25
r91 n95 n96 0.25
r92 n96 n97 0.25
r93 n97 n98 0.25
r94 n98 n99 0.25
r95 n99 n100 0.25
r96 n101 n102 0.25
r97 n102 n103 0.25
r98 n103 n104 0.25
r99 n104 n105 0.25
r100 n105 n106 0.25
r101 n106 n107 0.25
r102 n107 n108 0.25
r103 n108 n109 0.25
r104 n109 n110 0.25
r105 n110 n111 0.25
r106 n111 n112 0.25
r107 n112 n113 0.25
r108 n113 n114 0.25
r109 n114 n115 0.25
r110 n115 n116 0.25
r111 n116 n117 0.25
r112 n117 n118 0.25
r113 n118 n119 0.25
r114 n119 n120 0.25
r115 n121 n122 0.25
r116 n122 n123 0.25
r117 n123 n124 0.25
r118 n124 n125 0.25
r119 n125 n126 0.25
r120 n126 n127 0.25
r121 n127 n128 0.25
r122 n128 n129 0.25
r123 n129 n130 0.25
r124 n130 n131 0.25
r125 n131 n132 0.25
r126 n132 n133 0.25
r127 n133 n134 0.25
r128 n134 n135 0.25
r129 n135 n136 0.25
r130 n136 n137 0.25
r131 n137 n138 0.25
r132 n138 n139 0.25
r133 n139 n140 0.25
r134 n141 n142 0.25
r135 n142 n143 0.25
r136 n143 n144 0.25
r137 n144 n145 0.25
r138 n145 n146 0.25
r139 n146 n147 0.25
r140 n147 n148 0.25
r141 n148 n149 0.25
r142 n149 n150 0.25
r143 n150 n151 0.25
r144 n151 n152 0.25
r145 n152 n153 0.25
r146 n153 n154 0.25
r147 n154 n155 0.25
r148 n155 n156 0.25
r149 n156 n157 0.25
r150 n157 n158 0.25
r151 n158 n159 0.25
r152 n159 n160 0.25
r153 n161 n162 0.25
r154 n162 n163 0.25
r155 n163 n164 0.25
r156 n164 n165 0.25
r157 n165 n166 0.25
r158 n166 n167 0.25
r159 n167 n168 0.25
r160 n168 n169 0.25
r161 n169 n170 0.25
r162 n170 n171 0.25
r163 n171 n172 0.25
r164 n172 n173 0.25
r165 n173 n174 0.25
r166 n174 n175 0.25
r167 n175 n176 0.25
r168 n176 n177 0.25
r169 n177 n178 0.25
r170 n178 n179 0.25
r171 n179 n180 0.25
r172 n181 n182 0.25
r173 n182 n183 0.25
r174 n183 n184 0.25
r175 n184 n185 0.25
r176 n185 n186 0.25
r177 n186 n187 0.25
r178 n187 n188 0.25
r179 n188 n189 0.25
r180 n189 n190 0.25
r181 n190 n191 0.25
r182 n191 n192 0.25
r183 n192 n193 0.25
r184 n193 n194 0.25
r185 n194 n195 0.25
r186 n195 n196 0.25
r187 n196 n197 0.25
r188 n197 n198 0.25
r189 n198 n199 0.25
r190 n199 n200 0.25
r191 n201 n202 0.25
r192 n202 n203 0.25
r193 n203 n204 0.25
r194 n204 n205 0.25
r195 n205 n206 0.25
r196 n206 n207 0.25
r197 n207 n208 0.25
r198 n208 n209 0.25
r199 n209 n210 0.25
r200 n210 n211 0.25
r201 n211 n212 0.25
r202 n212 n213 0.25
r203 n213 n214 0.25
r204 n214 n215 0.25
r205 n215 n216 0.25
r206 n216 n217 0.25
r207 n217 n218 0.25
r208 n218 n219 0.25
r209 n219 n220 0.25
r210 n221 n222 0.25
r211 n222 n223 0.25
r212 n223 n224 0.25
r213 n224 n225 0.25
r214 n225 n226 0.25
r215 n226 n227 0.25
r216 n227 n228 0.25
r217 n228 n229 0.25
r218 n229 n230 0.25
r219 n230 n231 0.25
r220 n231 n232 0.25
r221 n232 n233 0.25
r222 n233 n234 0.25
r223 n234 n235 0.25
r224 n235 n236 0.25
r225 n236 n237 0.25
r226 n237 n238 0.25
r227 n238 n239 0.25
r228 n239 n240 0.25
r229 n241 n242 0.25
r230 n242 n243 0.25
r231 n243 n244 0.25
r232 n244 n245 0.25
r233 n245 n246 0.25
r234 n246 n247 0.25
r235 n247 n248 0.25
r236 n248 n249 0.25
r237 n249 n250 0.25
r238 n250 n251 0.25
r239 n251 n252 0.25
r240 n252 n253 0.25
r241 n253 n254 0.25
r242 n254 n255 0.25
r243 n255 n256 0.25
r244 n256 n257 0.25
r245 n257 n258 0.25
r246 n258 n259 0.25
r247 n259 n260 0.25
r248 n261 n262 0.25
r249 n262 n263 0.25
r250 n263 n264 0.25
r251 n264 n265 0.25
r252 n265 n266 0.25
r253 n266 n267 0.25
r254 n267 n268 0.25
r255 n268 n269 0.25
r256 n269 n270 0.25
r257 n270 n271 0.25
r258 n271 n272 0.25
r259 n272 n273 0.25
r260 n273 n274 0.25
r261 n274 n275 0.25
r262 n275 n276 0.25
r263 n276 n277 0.25
r264 n277 n278 0.25
r265 n278 n279 0.25
r266 n279 n280 0.25
r267 n281 n282 0.25
r268 n282 n283 0.25
r269 n283 n284 0.25
r270 n284 n285 0.25
r271 n285 n286 0.25
r272 n286 n287 0.25
r273 n287 n288 0.25
r274 n288 n289 0.25
r275 n289 n290 0.25
r276 n290 n291 0.25
r277 n291 n292 0.25
r278 n292 n293 0.25
r279 n293 n294 0.25
r280 n294 n295 0.25
r281 n295 n296 0.25
r282 n296 n297 0.25
r283 n297 n298 0.25
r284 n298 n299 0.25
r285 n299 n300 0.25
r286 n301 n302 0.25
r287 n302 n303 0.25
r288 n303 n304 0.25
r289 n304 n305 0.25
r290 n305 n306 0.25
r291 n306 n307 0.25
r292 n307 n308 0.25
r293 n308 n309 0.25
r294 n309 n310 0.25
r295 n310 n311 0.25
r296 n311 n312 0.25
r297 n312 n313 0.25
r298 n313 n314 0.25
r299 n314 n315 0.25
r300 n315 n316 0.25
r301 n316 n317 0.25
r302 n317 n318 0.25
r303 n318 n319 0.25
r304 n319 n320 0.25
r305 n321 n322 0.25
r306 n322 n323 0.25
r307 n323 n324 0.25
r308 n324 n325 0.25
r309 n325 n326 0.25
r310 n326 n327 0.25
r311 n327 n328 0.25
r312 n328 n329 0.25
r313 n329 n330 0.25
r314 n330 n331 0.25
r315 n331 n332 0.25
r316 n332 n333 0.25
r317 n333 n334 0.25
r318 n334 n335 0.25
r319 n335 n336 0.25
r320 n336 n337 0.25
r321 n337 n338 0.25
r322 n338 n339 0.25
r323 n339 n340 0.25
r324 n341 n342 0.25
r325 n342 n343 0.25
r326 n343 n344 0.25
r327 n344 n345 0.25
r328 n345 n346 0.25
r329 n346 n347 0.25
r330 n347 n348 0.25
r331 n348 n349 0.25
r332 n349 n350 0.25
r333 n350 n351 0.25
r334 n351 n352 0.25
r335 n352 n353 0.25
r336 n353 n354 0.25
r337 n354 n355 0.25
r338 n355 n356 0.25
r339 n356 n357 0.25
r340 n357 n358 0.25
r341 n358 n359 0.25
r342 n359 n360 0.25
r343 n361 n362 0.25
r344 n362 n363 0.25
r345 n363 n364 0.25
r346 n364 n365 0.25
r347 n365 n366 0.25
r348 n366 n367 0.25
r349 n367 n368 0.25
r350 n368 n369 0.25
r351 n369 n370 0.25
r352 n370 n371 0.25
r353 n371 n372 0.25
r354 n372 n373 0.25
r355 n373 n374 0.25
r356 n374 n375 0.25
r357 n375 n376 0.25
r358 n376 n377 0.25
r359 n377 n378 0.25
r360 n378 n379 0.25
r361 n379 n380 0.25
r362 n381 n382 0.25
r363 n382 n383 0.25
r364 n383 n384 0.25
r365 n384 n385 0.25
r366 n385 n386 0.25
r367 n386 n387 0.25
r368 n387 n388 0.25
r369 n388 n389 0.25
r370 n389 n390 0.25
r371 n390 n391 0.25
r372 n391 n392 0.25
r373 n392 n393 0.25
r374 n393 n394 0.25
r375 n394 n395 0.25
r376 n395 n396 0.25
r377 n396 n397 0.25
r378 n397 n398 0.25
r379 n398 n399 0.25
r380 n399 n400 0.25
r381 n1 n21 0.25
r382 n2 n22 0.25
r383 n3 n23 0.25
r384 n4 n24 0.25
r385 n5 n25 0.25
r386 n6 n26 0.25
r387 n7 n27 0.25
r388 n8 n28 0.25
r389 n9 n29 0.25
r390 n10 n30 0.25
r391 n11 n31 0.25
r392 n12 n32 0.25
r393 n13 n33 0.25
r394 n14 n34 0.25
r395 n15 n35 0.25
r396 n16 n36 0.25
r397 n17 n37 0.25
r398 n18 n38 0.25
r399 n19 n39 0.25
r400 n20 n40 0.25
r401 n21 n41 0.25
r402 n22 n42 0.25
r403 n23 n43 0.25
r404 n24 n44 0.25
r405 n25 n45 0.25
r406 n26 n46 0.25
r407 n27 n47 0.25
r408 n28 n48 0.25
r409 n29 n49 0.25
r410 n30 n50 0.25
r411 n31 n51 0.25
r412 n32 n52 0.25
r413 n33 n53 0.25
r414 n34 n54 0.25
r415 n35 n55 0.25
r416 n36 n56 0.25
r417 n37 n57 0.25
r418 n38 n58 0.25
r419 n39 n59 0.25
r420 n40 n60 0.25
r421 n41 n61 0.25
r422 n42 n62 0.25
r423 n43 n63 0.25
r424 n44 n64 0.25
r425 n45 n65 0.25
r426 n46 n66 0.25
r427 n47 n67 0.25
r428 n48 n68 0.25
r429 n49 n69 0.25
r430 n50 n70 0.25
r431 n51 n71 0.25
r432 n52 n72 0.25
r433 n53 n73 0.25
r434 n54 n74 0.25
r435 n55 n75 0.25
r436 n56 n76 0.25
r437 n57 n77 0.25
r438 n58 n78 0.25
r439 n59 n79 0.25
r440 n60 n80 0.25
r441 n61 n81 0.25
r442 n62 n82 0.25
r443 n63 n83 0.25
r444 n64 n84 0.25
r445 n65 n85 0.25
r446 n66 n86 0.25
r447 n67 n87 0.25
r448 n68 n88 0.25
r449 n69 n89 0.25
r450 n70 n90 0.25
r451 n71 n91 0.25
r452 n72 n92 0.25
r453 n73 n93 0.25
r454 n74 n94 0.25
r455 n75 n95 0.25
r456 n76 n96 0.25
r457 n77 n97 0.25
r458 n78 n98 0.25
r459 n79 n99 0.25
r460 n80 n100 0.25
r461 n81 n101 0.25
r462 n82 n102 0.25
r463 n83 n103 0.25
r464 n84 n104 0.25
r465 n85 n105 0.25
r466 n86 n106 0.25
r467 n87 n107 0.25
r468 n88 n108 0.25
r469 n89 n109 0.25
r470 n90 n110 0.25
r471 n91 n111 0.25
r472 n92 n112 0.25
r473 n93 n113 0.25
r474 n94 n114 0.25
r475 n95 n115 0.25
r476 n96 n116 0.25
r477 n97 n117 0.25
r478 n98 n118 0.25
r479 n99 n119 0.25
r480 n100 n120 0.25
r481 n101 n121 0.25
r482 n102 n122 0.25
r483 n103 n123 0.25
r484 n104 n124 0.25
r485 n105 n125 0.25
r486 n106 n126 0.25
r487 n107 n127 0.25
r488 n108 n128 0.25
r489 n109 n129 0.25
r490 n110 n130 0.25
r491 n111 n131 0.25
r492 n112 n132 0.25
r493 n113 n133 0.25
r494 n114 n134 0.25
r495 n115 n135 0.25
r496 n116 n136 0.25
r497 n117 n137 0.25
r498 n118 n138 0.25
r499 n119 n139 0.25
r500 n120 n140 0.25
r501 n121 n141 0.25
r502 n122 n142 0.25
r503 n123 n143 0.25
r504 n124 n144 0.25
r505 n125 n145 0.25
r506 n126 n146 0.25
r507 n127 n147 0.25
r508 n128 n148 0.25
r509 n129 n149 0.25
r510 n130 n150 0.25
r511 n131 n151 0.25
r512 n132 n152 0.25
r513 n133 n153 0.25
r514 n134 n154 0.25
r515 n135 n155 0.25
r516 n136 n156 0.25
r517 n137 n157 0.25
r518 n138 n158 0.25
r519 n139 n159 0.25
r520 n140 n160 0.25
r521 n141 n161 0.25
r522 n142 n162 0.25
r523 n143 n163 0.25
r524 n144 n164 0.25
r525 n145 n165 0.25
r526 n146 n166 0.25
r527 n147 n167 0.25
r528 n148 n168 0.25
r529 n149 n169 0.25
r530 n150 n170 0.25
r531 n151 n171 0.25
r532 n152 n172 0.25
r533 n153 n173 0.25
r534 n154 n174 0.25
r535 n155 n175 0.25
r536 n156 n176 0.25
r537 n157 n177 0.25
r538 n158 n178 0.25
r539 n159 n179 0.25
r540 n160 n180 0.25
r541 n161 n181 0.25
r542 n162 n182 0.25
r543 n163 n183 0.25
r544 n164 n184 0.25
r545 n165 n185 0.25
r546 n166 n186 0.25
r547 n167 n187 0.25
r548 n168 n188 0.25
r549 n169 n189 0.25
r550 n170 n190 0.25
r551 n171 n191 0.25
r552 n172 n192 0.25
r553 n173 n193 0.25
r554 n174 n194 0.25
r555 n175 n195 0.25
r556 n176 n196 0.25
r557 n177 n197 0.25
r558 n178 n198 0.25
r559 n179 n199 0.25
r560 n180 n200 0.25
r561 n181 n201 0.25
r562 n182 n202 0.25
r563 n183 n203 0.25
r564 n184 n204 0.25
r565 n185 n205 0.25
r566 n186 n206 0.25
r567 n187 n207 0.25
r568 n188 n208 0.25
r569 n189 n209 0.25
r570 n190 n210 0.25
r571 n191 n211 0.25
r572 n192 n212 0.25
r573 n193 n213 0.25
r574 n194 n214 0.25
r575 n195 n215 0.25
r576 n196 n216 0.25
r577 n197 n217 0.25
r578 n198 n218 0.25
r579 n199 n219 0.25
r580 n200 n220 0.25
r581 n201 n221 0.25
r582 n202 n222 0.25
r583 n203 n223 0.25
r584 n204 n224 0.25
r585 n205 n225 0.25
r586 n206 n226 0.25
r587 n207 n227 0.25
r588 n208 n228 0.25
r589 n209 n229 0.25
r590 n210 n230 0.25
r591 n211 n231 0.25
r592 n212 n232 0.25
r593 n213 n233 0.25
r594 n214 n234 0.25
r595 n215 n235 0.25
r596 n216 n236 0.25
r597 n217 n237 0.25
r598 n218 n238 0.25
r599 n219 n239 0.25
r600 n220 n240 0.25
r601 n221 n241 0.25
r602 n222 n242 0.25
r603 n223 n243 0.25
r604 n224 n244 0.25
r605 n225 n245 0.25
r606 n226 n246 0.25
r607 n227 n247 0.25
r608 n228 n248 0.25
r609 n229 n249 0.25
r610 n230 n250 0.25
r611 n231 n251 0.25
r612 n232 n252 0.25
r613 n233 n253 0.25
r614 n234 n254 0.25
r615 n235 n255 0.25
r616 n236 n256 0.25
r617 n237 n257 0.25
r618 n238 n258 0.25
r619 n239 n259 0.25
r620 n240 n260 0.25
r621 n241 n261 0.25
r622 n242 n262 0.25
r623 n243 n263 0.25
r624 n244 n264 0.25
r625 n245 n265 0.25
r626 n246 n266 0.25
r627 n247 n267 0.25
r628 n248 n268 0.25
r629 n249 n269 0.25
r630 n250 n270 0.25
r631 n251 n271 0.25
r632 n252 n272 0.25
r633 n253 n273 0.25
r634 n254 n274 0.25
r635 n255 n275 0.25
r636 n256 n276 0.25
r637 n257 n277 0.25
r638 n258 n278 0.25
r639 n259 n279 0.25
r640 n260 n280 0.25
r641 n261 n281 0.25
r642 n262 n282 0.25
r643 n263 n283 0.25
r644 n264 n284 0.25
r645 n265 n285 0.25
r646 n266 n286 0.25
r647 n267 n287 0.25
r648 n268 n288 0.25
r649 n269 n289 0.25
r650 n270 n290 0.25
r651 n271 n291 0.25
r652 n272 n292 0.25
r653 n273 n293 0.25
r654 n274 n294 0.25
r655 n275 n295 0.25
r656 n276 n296 0.25
r657 n277 n297 0.25
r658 n278 n298 0.25
r659 n279 n299 0.25
r660 n280 n300 0.25
r661 n281 n301 0.25
r662 n282 n302 0.25
r663 n283 n303 0.25
r664 n284 n304 0.25
r665 n285 n305 0.25
r666 n286 n306 0.25
r667 n287 n307 0.25
r668 n288 n308 0.25
r669 n289 n309 0.25
r670 n290 n310 0.25
r671 n291 n311 0.25
r672 n292 n312 0.25
r673 n293 n313 0.25
r674 n294 n314 0.25
r675 n295 n315 0.25
r676 n296 n316 0.25
r677 n297 n317 0.25
r678 n298 n318 0.25
r679 n299 n319 0.25
r680 n300 n320 0.25
r681 n301 n321 0.25
r682 n302 n322 0.25
r683 n303 n323 0.25
r684 n304 n324 0.25
r685 n305 n325 0.25
r686 n306 n326 0.25
r687 n307 n327 0.25
r688 n308 n328 0.25
r689 n309 n329 0.25
r690 n310 n330 0.25
r691 n311 n331 0.25
r692 n312 n332 0.25
r693 n313 n333 0.25
r694 n314 n334 0.25
r695 n315 n335 0.25
r696 n316 n336 0.25
r697 n317 n337 0.25
r698 n318 n338 0.25
r699 n319 n339 0.25
r700 n320 n340 0.25
r701 n321 n341 0.25
r702 n322 n342 0.25
r703 n323 n343 0.25
r704 n324 n344 0.25
r705 n325 n345 0.25
r706 n326 n346 0.25
r707 n327 n347 0.25
r708 n328 n348 0.25
r709 n329 n349 0.25
r710 n330 n350 0.25
r711 n331 n351 0.25
r712 n332 n352 0.25
r713 n333 n353 0.25
r714 n334 n354 0.25
r715 n335 n355 0.25
r716 n336 n356 0.25
r717 n337 n357 0.25
r718 n338 n358 0.25
r719 n339 n359 0.25
r720 n340 n360 0.25
r721 n341 n361 0.25
r722 n342 n362 0.25
r723 n343 n363 0.25
r724 n344 n364 0.25
r725 n345 n365 0.25
r726 n346 n366 0.25
r727 n347 n367 0.25
r728 n348 n368 0.25
r729 n349 n369 0.25
r730 n350 n370 0.25
r731 n351 n371 0.25
r732 n352 n372 0.25
r733 n353 n373 0.25
r734 n354 n374 0.25
r735 n355 n375 0.25
r736 n356 n376 0.25
r737 n357 n377 0.25
r738 n358 n378 0.25
r739 n359 n379 0.25
r740 n360 n380 0.25
r741 n361 n381 0.25
r742 n362 n382 0.25
r743 n363 n383 0.25
r744 n364 n384 0.25
r745 n365 n385 0.25
r746 n366 n386 0.25
r747 n367 n387 0.25
r748 n368 n388 0.25
r749 n369 n389 0.25
r750 n370 n390 0.25
r751 n371 n391 0.25
r752 n372 n392 0.25
r753 n373 n393 0.25
r754 n374 n394 0.25
r755 n375 n395 0.25
r756 n376 n396 0.25
r757 n377 n397 0.25
r758 n378 n398 0.25
r759 n379 n399 0.25
r760 n380 n400 0.25
*load
i0 n154 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c0 n154 gnd 5e-10
i1 n155 gnd pwl .35e-6 0 .4e-6 0.006 .45e-6 0
c1 n155 gnd 3.0000000000000004e-09
i2 n75 gnd pwl .35e-6 0 .4e-6 0.006 .45e-6 0
c2 n75 gnd 3.0000000000000004e-09
i3 n74 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c3 n74 gnd 5e-10
i4 n157 gnd pwl .35e-6 0 .4e-6 0.004 .45e-6 0
c4 n157 gnd 2e-09
i5 n76 gnd pwl .35e-6 0 .4e-6 0.004 .45e-6 0
c5 n76 gnd 2e-09
i6 n19 gnd pwl .35e-6 0 .4e-6 0.003 .45e-6 0
c6 n19 gnd 1.5000000000000002e-09
i7 n159 gnd pwl .35e-6 0 .4e-6 0.012 .45e-6 0
c7 n159 gnd 6.000000000000001e-09
i8 n157 gnd pwl .35e-6 0 .4e-6 0.012 .45e-6 0
c8 n157 gnd 6.000000000000001e-09
i9 n17 gnd pwl .35e-6 0 .4e-6 0.003 .45e-6 0
c9 n17 gnd 1.5000000000000002e-09
i10 n234 gnd pwl .35e-6 0 .4e-6 0.014 .45e-6 0
c10 n234 gnd 7.000000000000001e-09
i11 n239 gnd pwl .35e-6 0 .4e-6 0.014 .45e-6 0
c11 n239 gnd 7.000000000000001e-09
i12 n159 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c12 n159 gnd 5e-10
i13 n154 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c13 n154 gnd 5e-10
i14 n152 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c14 n152 gnd 5e-10
i15 n174 gnd pwl .35e-6 0 .4e-6 0.004 .45e-6 0
c15 n174 gnd 2e-09
i16 n212 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c16 n212 gnd 5e-10
i17 n212 gnd pwl .35e-6 0 .4e-6 0.004 .45e-6 0
c17 n212 gnd 2e-09
i18 n12 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c18 n12 gnd 5e-10
i19 n74 gnd pwl .35e-6 0 .4e-6 0.011 .45e-6 0
c19 n74 gnd 5.5000000000000004e-09
i20 n16 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c20 n16 gnd 5e-10
i21 n12 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c21 n12 gnd 5e-10
i22 n14 gnd pwl .35e-6 0 .4e-6 0.01 .45e-6 0
c22 n14 gnd 5e-09
i23 n335 gnd pwl .35e-6 0 .4e-6 0.009 .45e-6 0
c23 n335 gnd 4.5e-09
i24 n399 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c24 n399 gnd 5e-10
i25 n339 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c25 n339 gnd 5e-10
i26 n319 gnd pwl .35e-6 0 .4e-6 0.004 .45e-6 0
c26 n319 gnd 2e-09
i27 n315 gnd pwl .35e-6 0 .4e-6 0.005 .45e-6 0
c27 n315 gnd 2.5e-09
i28 n72 gnd pwl .35e-6 0 .4e-6 0.007 .45e-6 0
c28 n72 gnd 3.5000000000000003e-09
i29 n154 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c29 n154 gnd 5e-10
i30 n152 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c30 n152 gnd 5e-10
i31 n152 gnd pwl .35e-6 0 .4e-6 0.007 .45e-6 0
c31 n152 gnd 3.5000000000000003e-09
i32 n255 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c32 n255 gnd 5e-10
i33 n375 gnd pwl .35e-6 0 .4e-6 0.009 .45e-6 0
c33 n375 gnd 4.5e-09
i34 n252 gnd pwl .35e-6 0 .4e-6 0.005 .45e-6 0
c34 n252 gnd 2.5e-09
i35 n372 gnd pwl .35e-6 0 .4e-6 0.005 .45e-6 0
c35 n372 gnd 2.5e-09
i36 n315 gnd pwl .35e-6 0 .4e-6 0.009 .45e-6 0
c36 n315 gnd 4.5e-09
i37 n319 gnd pwl .35e-6 0 .4e-6 0.009 .45e-6 0
c37 n319 gnd 4.5e-09
i38 n239 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c38 n239 gnd 5e-10
i39 n236 gnd pwl .35e-6 0 .4e-6 0.001 .45e-6 0
c39 n236 gnd 5e-10
i40 n6 gnd pwl .35e-6 0 .4e-6 0.2 .45e-6 0
c40 n6 gnd 1.0000000000000002e-07
i41 n386 gnd pwl .35e-6 0 .4e-6 0.2 .45e-6 0
c41 n386 gnd 1.0000000000000002e-07
*pdn
iin nn0 gnd -1e3
Rp0 nn0 gnd 1e-3
Rp1 nn0 nn01 10e-3
Lp1 nn01 nn02 1e-9
Cp1 nn02 0 1000e-6
Rp2 nn0 nn1 1e-3
Lp2 nn1 nn2 10e-9
Rp3 nn2 nn21 12e-3
Lp3 nn21 nn22 500e-12
Cp3 nn22 0 25e-6
Rp4 nn2 nn3 1e-3
Lp4 nn3 nn4 200e-12
Rp5 nn4 nn41 15e-3
Lp5 nn41 nn42 100e-12
Cp5 nn42 0 500e-9
Rp6 nn4 nn5 1e-3
Lp6 nn5 nn6 30e-9
Rp7 nn6 n1 5e-3
Cp7 n1 0 1e-9
*voltage source
*simulation options
.tran 0 2e-6 0.001e-6
.probe n1
